# Keil uVision project MyPrj.uvprojx, settings and files
target STM32F103ZET6 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyPrj +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\BSP;..\USER;.\RTE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c
  group BSP
    ../BSP/: led.c key.c exti.c bsp.c beep.c beep.h bsp.h Delay.c Delay.h exti.h key.h led.h
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:GPIO 1.3, Device:Startup 1.0.0
