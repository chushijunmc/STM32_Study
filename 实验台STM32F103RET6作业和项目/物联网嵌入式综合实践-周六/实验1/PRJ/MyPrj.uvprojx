# Keil uVision project MyPrj.uvprojx, settings and files
target STM32F103ZET6 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyPrj +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\BSP;..\USER;.\RTE;..\STM32F10x_FWLib;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\SYSTEM\spi;..\SYSTEM\sys
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c Delay.c
  group BSP
    ../BSP/: led.c bsp.c key.c beep.c exti.c tim.c systick.c lcd.c
  group LIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c
    ../STM32F10x_FWLib/inc/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group SYSTEM
    ../SYSTEM/spi/: spi.c
    ../SYSTEM/sys/: sys.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, Device:GPIO 1.3, Device:Startup 1.0.0
